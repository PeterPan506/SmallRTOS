# Keil uVision project SmallRTOSDemo.uvproj, settings and files
target SmallRTOSDemo (ARM-ADS)
  device: STM32F030C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0")
  output: SmallRTOSDemo +hex
  c flags: Optim=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F0XX
  c include: ..\..\Kernel\OS;..\..\Kernel\CPU\KEIL\ARM_CM0;.\library\STM32F0xx_StdPeriph_Driver\inc;.\core\CMSIS\Include;.\core\CMSIS\Device\ST\STM32F0xx\Include;.\user
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group SmallRTOS
    ../../Kernel/CPU/KEIL/ARM_CM0/: FitCPU.c FitCPU.h FitType.h
    ../../Kernel/OS/: OSList.c OSList.h OSMemory.c OSMemory.h OSMsgQ.c OSMsgQ.h OSMutex.c OSMutex.h OSQueue.c OSQueue.h OSSemaphore.c OSSemaphore.h OSTask.c OSTask.h OSTimer.c OSTimer.h OSType.h SmallRTOS.h
  group core
    ./core/CMSIS/Device/ST/STM32F0xx/Source/Templates/arm/: startup_stm32f0xx.s
    ./core/CMSIS/Device/ST/STM32F0xx/Include/: stm32f0xx.h system_stm32f0xx.h
    ./core/CMSIS/Device/ST/STM32F0xx/Source/Templates/: system_stm32f0xx.c
  group library
    ./library/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_adc.c stm32f0xx_can.c stm32f0xx_cec.c stm32f0xx_comp.c stm32f0xx_crc.c stm32f0xx_crs.c stm32f0xx_dac.c stm32f0xx_dbgmcu.c stm32f0xx_dma.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_i2c.c stm32f0xx_iwdg.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_rtc.c stm32f0xx_spi.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_usart.c stm32f0xx_wwdg.c
  group user
    ./user/: main.c SmallRTOSConfig.h stm32f0xx_conf.h stm32f0xx_it.c stm32f0xx_it.h
