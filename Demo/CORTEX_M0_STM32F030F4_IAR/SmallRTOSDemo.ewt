<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>board</name>
  </group>
  <group>
    <name>core</name>
    <file>
      <name>$PROJ_DIR$\core\CMSIS\Device\ST\STM32F0xx\Source\Templates\iar\startup_stm32f0xx.s</name>
    </file>
    <file>
      <name>$PROJ_DIR$\core\CMSIS\Device\ST\STM32F0xx\Include\stm32f0xx.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\core\CMSIS\Device\ST\STM32F0xx\Source\Templates\system_stm32f0xx.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\core\CMSIS\Device\ST\STM32F0xx\Include\system_stm32f0xx.h</name>
    </file>
  </group>
  <group>
    <name>library</name>
    <file>
      <name>$PROJ_DIR$\library\STM32F0xx_StdPeriph_Driver\src\stm32f0xx_adc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\library\STM32F0xx_StdPeriph_Driver\src\stm32f0xx_can.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\library\STM32F0xx_StdPeriph_Driver\src\stm32f0xx_cec.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\library\STM32F0xx_StdPeriph_Driver\src\stm32f0xx_comp.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\library\STM32F0xx_StdPeriph_Driver\src\stm32f0xx_crc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\library\STM32F0xx_StdPeriph_Driver\src\stm32f0xx_crs.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\library\STM32F0xx_StdPeriph_Driver\src\stm32f0xx_dac.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\library\STM32F0xx_StdPeriph_Driver\src\stm32f0xx_dbgmcu.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\library\STM32F0xx_StdPeriph_Driver\src\stm32f0xx_dma.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\library\STM32F0xx_StdPeriph_Driver\src\stm32f0xx_exti.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\library\STM32F0xx_StdPeriph_Driver\src\stm32f0xx_flash.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\library\STM32F0xx_StdPeriph_Driver\src\stm32f0xx_gpio.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\library\STM32F0xx_StdPeriph_Driver\src\stm32f0xx_i2c.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\library\STM32F0xx_StdPeriph_Driver\src\stm32f0xx_iwdg.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\library\STM32F0xx_StdPeriph_Driver\src\stm32f0xx_misc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\library\STM32F0xx_StdPeriph_Driver\src\stm32f0xx_pwr.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\library\STM32F0xx_StdPeriph_Driver\src\stm32f0xx_rcc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\library\STM32F0xx_StdPeriph_Driver\src\stm32f0xx_rtc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\library\STM32F0xx_StdPeriph_Driver\src\stm32f0xx_spi.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\library\STM32F0xx_StdPeriph_Driver\src\stm32f0xx_syscfg.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\library\STM32F0xx_StdPeriph_Driver\src\stm32f0xx_tim.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\library\STM32F0xx_StdPeriph_Driver\src\stm32f0xx_usart.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\library\STM32F0xx_StdPeriph_Driver\src\stm32f0xx_wwdg.c</name>
    </file>
  </group>
  <group>
    <name>SmallRTOS</name>
    <group>
      <name>CPU</name>
      <file>
        <name>$PROJ_DIR$\..\..\Kernel\CPU\IAR\ARM_CM0\FitAsm.s</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Kernel\CPU\IAR\ARM_CM0\FitCPU.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Kernel\CPU\IAR\ARM_CM0\FitCPU.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Kernel\CPU\IAR\ARM_CM0\FitType.h</name>
      </file>
    </group>
    <group>
      <name>OS</name>
      <file>
        <name>$PROJ_DIR$\..\..\Kernel\OS\OSList.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Kernel\OS\OSList.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Kernel\OS\OSMemory.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Kernel\OS\OSMemory.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Kernel\OS\OSMsgQ.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Kernel\OS\OSMsgQ.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Kernel\OS\OSMutex.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Kernel\OS\OSMutex.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Kernel\OS\OSQueue.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Kernel\OS\OSQueue.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Kernel\OS\OSSemaphore.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Kernel\OS\OSSemaphore.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Kernel\OS\OSTask.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Kernel\OS\OSTask.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Kernel\OS\OSTimer.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Kernel\OS\OSTimer.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Kernel\OS\OSType.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Kernel\OS\SmallRTOS.h</name>
      </file>
    </group>
  </group>
  <group>
    <name>user</name>
    <file>
      <name>$PROJ_DIR$\user\main.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\user\SmallRTOSConfig.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\user\stm32f0xx_conf.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\user\stm32f0xx_it.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\user\stm32f0xx_it.h</name>
    </file>
  </group>
</project>


