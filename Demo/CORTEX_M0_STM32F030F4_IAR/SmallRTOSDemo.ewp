# IAR project SmallRTOSDemo.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F030x4 ST STM32F030x4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F0XX
  ICCARM.CCIncludePath2: user; core\CMSIS\Include; core\CMSIS\Device\ST\STM32F0xx\Include; board; library\STM32F0xx_StdPeriph_Driver\inc; ..\..\Kernel\CPU\IAR\ARM_CM0; ..\..\Kernel\OS\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: user
  OBJCOPY.OOCOutputFile: SmallRTOSDemo.srec
  ILINK.IlinkOutputFile: SmallRTOSDemo.out
  ILINK.IlinkIcfFile: SmallRTOSDemo.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group core
    core/CMSIS/Device/ST/STM32F0xx/Source/Templates/iar/: startup_stm32f0xx.s
    core/CMSIS/Device/ST/STM32F0xx/Include/: stm32f0xx.h system_stm32f0xx.h
    core/CMSIS/Device/ST/STM32F0xx/Source/Templates/: system_stm32f0xx.c
  group library
    library/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_adc.c stm32f0xx_can.c stm32f0xx_cec.c stm32f0xx_comp.c stm32f0xx_crc.c stm32f0xx_crs.c stm32f0xx_dac.c stm32f0xx_dbgmcu.c stm32f0xx_dma.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_i2c.c stm32f0xx_iwdg.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_rtc.c stm32f0xx_spi.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_usart.c stm32f0xx_wwdg.c
  group SmallRTOS/CPU
    ../../Kernel/CPU/IAR/ARM_CM0/: FitAsm.s FitCPU.c FitCPU.h FitType.h
  group SmallRTOS/OS
    ../../Kernel/OS/: OSList.c OSList.h OSMemory.c OSMemory.h OSMsgQ.c OSMsgQ.h OSMutex.c OSMutex.h OSQueue.c OSQueue.h OSSemaphore.c OSSemaphore.h OSTask.c OSTask.h OSTimer.c OSTimer.h OSType.h SmallRTOS.h
  group user
    user/: main.c SmallRTOSConfig.h stm32f0xx_conf.h stm32f0xx_it.c stm32f0xx_it.h
