# Keil uVision project SmallRTOSDemo.uvproj, settings and files
target SmallRTOSDemo (ARM-ADS)
  device: STM32F407ZG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: SmallRTOSDemo +hex
  c flags: Optim=1 wLevel=2
  c define: STM32F40_41xxx, USE_STDPERIPH_DRIVER
  c include: .\library\STM32F4xx_StdPeriph_Driver\inc;.\core;.\board;.\user;..\..\Kernel\OS;..\..\Kernel\CPU\KEIL\ARM_CM4F
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group SmallRTOS
    ../../Kernel/CPU/KEIL/ARM_CM4F/: FitCPU.c FitCPU.h FitType.h
    ../../Kernel/OS/: OSList.c OSList.h OSMemory.c OSMemory.h OSMsgQ.c OSMsgQ.h OSMutex.c OSMutex.h OSQueue.c OSQueue.h OSSemaphore.c OSSemaphore.h OSTask.c OSTask.h OSTimer.c OSTimer.h OSType.h SmallRTOS.h
  group library
    ./library/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group core
    ./core/: core_cm4.h core_cm4_simd.h core_cmFunc.h core_cmInstr.h startup_stm32f40_41xxx.s
  group board
    ./board/: stm32f407zg_sk.c stm32f407zg_sk.h
  group user
    ./user/: main.c stm32f4xx.h stm32f4xx_conf.h stm32f4xx_it.c stm32f4xx_it.h system_stm32f4xx.c system_stm32f4xx.h SmallRTOSConfig.h
