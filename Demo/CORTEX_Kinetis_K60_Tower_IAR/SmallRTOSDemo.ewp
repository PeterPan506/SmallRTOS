# IAR project SmallRTOSDemo.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK60DN512Zxxx10 Freescale MK60DN512Zxxx10
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: IAR; TWR_K60N512
  ICCARM.CCIncludePath2: ..\..\Kernel\CPU\IAR\ARM_CM3; ..\..\Kernel\OS\; Freescale\core; Freescale\common; Freescale\cpu; Freescale\drivers\uart; Freescale\drivers\mcg; Freescale\drivers\wdog; Freescale\drivers\adc16; Freescale\drivers\enet; Freescale\drivers\gpio; user
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: user
  ILINK.IlinkOutputFile: SmallRTOSDemo.out
  ILINK.IlinkIcfFile: Freescale\common\512KB_Pflash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Freescale/common
    Freescale/common/: startup.c
  group Freescale/cpu
    Freescale/cpu/: arm_cm4.c crt0.s start.c sysinit.c
  group Freescale/drivers/enet
    Freescale/drivers/enet/: enet.c eth_phy.c mii.c
  group Freescale/drivers/gpio
    Freescale/drivers/gpio/: gpio.c
  group Freescale/drivers/mcg
    Freescale/drivers/mcg/: mcg.c
  group Freescale/drivers/uart
    Freescale/drivers/uart/: uart.c
  group Freescale/drivers/wdog
    Freescale/drivers/wdog/: wdog.c
  group SmallRTOS/CPU
    ../../Kernel/CPU/IAR/ARM_CM3/: FitAsm.s FitCPU.c FitCPU.h FitType.h
  group SmallRTOS/OS
    ../../Kernel/OS/: OSList.c OSList.h OSMemory.c OSMemory.h OSMsgQ.c OSMsgQ.h OSMutex.c OSMutex.h OSQueue.c OSQueue.h OSSemaphore.c OSSemaphore.h OSTask.c OSTask.h OSTimer.c OSTimer.h OSType.h SmallRTOS.h
  group user
    user/: main.c MK60DZ10.h SmallRTOSConfig.h system_MK60DZ10.c system_MK60DZ10.h
