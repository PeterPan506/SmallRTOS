<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>Freescale</name>
    <group>
      <name>common</name>
      <file>
        <name>$PROJ_DIR$\Freescale\common\startup.c</name>
      </file>
    </group>
    <group>
      <name>cpu</name>
      <file>
        <name>$PROJ_DIR$\Freescale\cpu\arm_cm4.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Freescale\cpu\crt0.s</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Freescale\cpu\start.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Freescale\cpu\sysinit.c</name>
      </file>
    </group>
    <group>
      <name>drivers</name>
      <group>
        <name>enet</name>
        <file>
          <name>$PROJ_DIR$\Freescale\drivers\enet\enet.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Freescale\drivers\enet\eth_phy.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Freescale\drivers\enet\mii.c</name>
        </file>
      </group>
      <group>
        <name>gpio</name>
        <file>
          <name>$PROJ_DIR$\Freescale\drivers\gpio\gpio.c</name>
        </file>
      </group>
      <group>
        <name>mcg</name>
        <file>
          <name>$PROJ_DIR$\Freescale\drivers\mcg\mcg.c</name>
        </file>
      </group>
      <group>
        <name>uart</name>
        <file>
          <name>$PROJ_DIR$\Freescale\drivers\uart\uart.c</name>
        </file>
      </group>
      <group>
        <name>wdog</name>
        <file>
          <name>$PROJ_DIR$\Freescale\drivers\wdog\wdog.c</name>
        </file>
      </group>
    </group>
  </group>
  <group>
    <name>SmallRTOS</name>
    <group>
      <name>CPU</name>
      <file>
        <name>$PROJ_DIR$\..\..\Kernel\CPU\IAR\ARM_CM3\FitAsm.s</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Kernel\CPU\IAR\ARM_CM3\FitCPU.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Kernel\CPU\IAR\ARM_CM3\FitCPU.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Kernel\CPU\IAR\ARM_CM3\FitType.h</name>
      </file>
    </group>
    <group>
      <name>OS</name>
      <file>
        <name>$PROJ_DIR$\..\..\Kernel\OS\OSList.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Kernel\OS\OSList.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Kernel\OS\OSMemory.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Kernel\OS\OSMemory.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Kernel\OS\OSMsgQ.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Kernel\OS\OSMsgQ.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Kernel\OS\OSMutex.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Kernel\OS\OSMutex.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Kernel\OS\OSQueue.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Kernel\OS\OSQueue.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Kernel\OS\OSSemaphore.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Kernel\OS\OSSemaphore.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Kernel\OS\OSTask.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Kernel\OS\OSTask.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Kernel\OS\OSTimer.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Kernel\OS\OSTimer.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Kernel\OS\OSType.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Kernel\OS\SmallRTOS.h</name>
      </file>
    </group>
  </group>
  <group>
    <name>user</name>
    <file>
      <name>$PROJ_DIR$\user\main.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\user\MK60DZ10.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\user\SmallRTOSConfig.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\user\system_MK60DZ10.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\user\system_MK60DZ10.h</name>
    </file>
  </group>
</project>


