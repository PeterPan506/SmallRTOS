# IAR project SmallRTOSDemo.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F107xC ST STM32F107xC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_CL
  ICCARM.CCIncludePath2: user; core\CMSIS\CM3\CoreSupport; core\CMSIS\CM3\DeviceSupport\ST\STM32F10x; board; library\STM32F10x_StdPeriph_Driver\inc; ..\..\Kernel\CPU\IAR\ARM_CM3; ..\..\Kernel\OS\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: user
  OBJCOPY.OOCOutputFile: SmallRTOSDemo.srec
  ILINK.IlinkOutputFile: SmallRTOSDemo.out
  ILINK.IlinkIcfFile: SmallRTOSDemo.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group board
    board/: HardwareInit.c HardwareInit.h LED.C LED.h
  group core
    core/CMSIS/CM3/CoreSupport/: core_cm3.c core_cm3.h
    core/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group library
    library/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group SmallRTOS/CPU
    ../../Kernel/CPU/IAR/ARM_CM3/: FitAsm.s FitCPU.c FitCPU.h FitType.h
  group SmallRTOS/OS
    ../../Kernel/OS/: OSList.c OSList.h OSMemory.c OSMemory.h OSMsgQ.c OSMsgQ.h OSMutex.c OSMutex.h OSQueue.c OSQueue.h OSSemaphore.c OSSemaphore.h OSTask.c OSTask.h OSTimer.c OSTimer.h OSType.h SmallRTOS.h
  group user
    user/: main.c SmallRTOSConfig.h stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
