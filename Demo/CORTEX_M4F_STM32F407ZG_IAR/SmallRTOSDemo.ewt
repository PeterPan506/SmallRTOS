<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>board</name>
    <file>
      <name>$PROJ_DIR$\board\iar_stm32f407zg_sk.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\board\iar_stm32f407zg_sk.h</name>
    </file>
  </group>
  <group>
    <name>core</name>
    <file>
      <name>$PROJ_DIR$\core\core_cm4.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\core\core_cm4_simd.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\core\core_cmFunc.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\core\core_cmInstr.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\core\startup_stm32f40_41xxx.s</name>
    </file>
  </group>
  <group>
    <name>library</name>
    <group>
      <name>STM32F4xx_StdPeriph_Driver</name>
      <file>
        <name>$PROJ_DIR$\library\STM32F4xx_StdPeriph_Driver\src\misc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\library\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_adc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\library\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_can.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\library\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_crc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\library\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_cryp.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\library\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_cryp_aes.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\library\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_cryp_des.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\library\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_cryp_tdes.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\library\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_dac.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\library\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_dbgmcu.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\library\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_dcmi.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\library\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_dma.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\library\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_exti.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\library\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_flash.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\library\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_fsmc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\library\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_gpio.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\library\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_hash.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\library\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_hash_md5.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\library\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_hash_sha1.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\library\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_i2c.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\library\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_iwdg.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\library\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_pwr.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\library\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_rcc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\library\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_rng.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\library\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_rtc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\library\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_sdio.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\library\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_spi.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\library\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_syscfg.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\library\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_tim.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\library\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_usart.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\library\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_wwdg.c</name>
      </file>
    </group>
  </group>
  <group>
    <name>SmallRTOS</name>
    <group>
      <name>CPU</name>
      <file>
        <name>$PROJ_DIR$\..\..\Kernel\CPU\IAR\ARM_CM4F\FitAsm.s</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Kernel\CPU\IAR\ARM_CM4F\FitCPU.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Kernel\CPU\IAR\ARM_CM4F\FitCPU.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Kernel\CPU\IAR\ARM_CM4F\FitType.h</name>
      </file>
    </group>
    <group>
      <name>OS</name>
      <file>
        <name>$PROJ_DIR$\..\..\Kernel\OS\OSList.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Kernel\OS\OSList.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Kernel\OS\OSMemory.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Kernel\OS\OSMemory.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Kernel\OS\OSMsgQ.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Kernel\OS\OSMsgQ.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Kernel\OS\OSMutex.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Kernel\OS\OSMutex.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Kernel\OS\OSQueue.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Kernel\OS\OSQueue.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Kernel\OS\OSSemaphore.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Kernel\OS\OSSemaphore.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Kernel\OS\OSTask.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Kernel\OS\OSTask.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Kernel\OS\OSTimer.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Kernel\OS\OSTimer.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Kernel\OS\OSType.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Kernel\OS\SmallRTOS.h</name>
      </file>
    </group>
  </group>
  <group>
    <name>user</name>
    <file>
      <name>$PROJ_DIR$\user\main.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\user\SmallRTOSConfig.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\user\stm32f4xx.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\user\stm32f4xx_conf.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\user\stm32f4xx_it.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\user\stm32f4xx_it.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\user\system_stm32f4xx.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\user\system_stm32f4xx.h</name>
    </file>
  </group>
</project>


