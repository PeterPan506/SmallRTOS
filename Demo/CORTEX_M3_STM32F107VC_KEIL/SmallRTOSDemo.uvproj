# Keil uVision project SmallRTOSDemo.uvproj, settings and files
target SmallRTOSDemo (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: SmallRTOSDemo +hex
  c flags: Optim=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_CL
  c include: ..\..\Kernel\OS;..\..\Kernel\CPU\KEIL\ARM_CM3;.\library\STM32F10x_StdPeriph_Driver\inc;.\core\CMSIS\CM3\CoreSupport;.\core\CMSIS\CM3\DeviceSupport\ST\STM32F10x;.\board;.\user
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group SmallRTOS
    ../../Kernel/CPU/KEIL/ARM_CM3/: FitCPU.c FitCPU.h FitType.h
    ../../Kernel/OS/: OSList.c OSList.h OSMemory.c OSMemory.h OSMsgQ.c OSMsgQ.h OSMutex.c OSMutex.h OSQueue.c OSQueue.h OSSemaphore.c OSSemaphore.h OSTask.c OSTask.h OSTimer.c OSTimer.h OSType.h SmallRTOS.h
  group library
    ./library/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group board
    ./board/: LED.C LED.h HardwareInit.c HardwareInit.h
  group core
    ./core/CMSIS/CM3/CoreSupport/: core_cm3.c core_cm3.h
    ./core/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: stm32f10x.h system_stm32f10x.h system_stm32f10x.c
    ./core/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_cl.s
  group user
    ./user/: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h SmallRTOSConfig.h
