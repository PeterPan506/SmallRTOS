# Keil uVision project SmallRTOSDemo.uvproj, settings and files
target SmallRTOSDemo (ARM-ADS)
  device: MK60DN512xxx10 Freescale
  cpu: IRAM(0x1FFF0000-0x1FFFFFFF) IRAM2(0x20000000-0x2000FFFF) IROM(0x0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M4") ELITTLE
  output: SmallRTOSDemo +hex
  c flags: Optim=1 wLevel=2
  c define: TWR_K60N512
  c include: ..\..\Kernel\OS;..\..\Kernel\CPU\KEIL\ARM_CM3;.\Freescale\core;.\Freescale\cpu;.\Freescale\drivers;.\user
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x10000
  group SmallRTOS
    ../../Kernel/CPU/KEIL/ARM_CM3/: FitCPU.c FitCPU.h FitType.h
    ../../Kernel/OS/: OSList.c OSList.h OSMemory.c OSMemory.h OSMsgQ.c OSMsgQ.h OSMutex.c OSMutex.h OSQueue.c OSQueue.h OSSemaphore.c OSSemaphore.h OSTask.c OSTask.h OSTimer.c OSTimer.h OSType.h SmallRTOS.h
  group Freescale
    ./Freescale/cpu/: startup_MK60DZ10.s
    ./Freescale/drivers/: gpio.c
  group user
    ./user/: main.c SmallRTOSConfig.h system_MK60DZ10.c
